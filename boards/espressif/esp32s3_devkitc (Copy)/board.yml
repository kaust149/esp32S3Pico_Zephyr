## boards/espressif/esp32s3_devkitc (Copy)/board.yml
```yaml
board:
  name: esp32s3_devkitc_t
  full_name: ESP32-S3-DevKitC
  vendor: espressif
  socs:
  - name: esp32s3
```
